<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\thermomodule_without_trustzone.ewp</path>
    </project>
    <batchBuild />
</workspace>
