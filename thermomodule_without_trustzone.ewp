# IAR project thermomodule_without_trustzone.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32U385CG ST STM32U385CG
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCIncludePath2: CMSIS\; libraries\; drivers\; application\; middleware\; CMSIS\CMSIS-DSP\; CMSIS\CMSIS-DSP\dsp
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: thermomodule_without_trustzone.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: CMSIS\stm32u385xx_flash.icf
  ILINK.IlinkAdditionalLibs: C:\Documents\IAREWARM\thermomodule_without_trustzone\CMSIS\CMSIS-DSP\Lib\iar_ARMv8MMLlfsp_math.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group (top)
    ./: main.cpp
  group application
    application/: fdcan_control.h logging.h thermo.h
  group CMSIS
    CMSIS/: armv8m_mpu.h armv8m_pmu.h cmsis_compiler.h cmsis_iccarm.h cmsis_iccarm_m.h cmsis_version.h core_cm33.h partition_stm32u385xx.h partition_stm32u3xx.h startup_stm32u385xx.s stm32u385xx.h stm32u3xx.h system_stm32u3xx.c system_stm32u3xx.h tz_context.h
  group CMSIS/CMSIS-DSP
    CMSIS/CMSIS-DSP/: arm_common_tables.h arm_common_tables_f16.h arm_const_structs.h arm_const_structs_f16.h arm_helium_utils.h arm_math.h arm_math_f16.h arm_math_memory.h arm_math_types.h arm_math_types_f16.h arm_mve_tables.h arm_mve_tables_f16.h arm_neon_tables.h arm_neon_tables_f16.h arm_vec_math.h arm_vec_math_f16.h
  group CMSIS/CMSIS-DSP/dsp
    CMSIS/CMSIS-DSP/dsp/: basic_math_functions.h basic_math_functions_f16.h bayes_functions.h bayes_functions_f16.h complex_math_functions.h complex_math_functions_f16.h controller_functions.h controller_functions_f16.h debug.h distance_functions.h distance_functions_f16.h fast_math_functions.h fast_math_functions_f16.h filtering_functions.h filtering_functions_f16.h interpolation_functions.h interpolation_functions_f16.h matrix_functions.h matrix_functions_f16.h matrix_utils.h none.h quaternion_math_functions.h statistics_functions.h statistics_functions_f16.h support_functions.h support_functions_f16.h svm_defines.h svm_functions.h svm_functions_f16.h transform_functions.h transform_functions_f16.h utils.h window_functions.h
  group drivers
    drivers/: clock.h crc.h fdcan.h gpdma.h gpio.h octospi.h rng.h rtc.h spilite.h swo.h wdg.h
  group libraries
    libraries/: ads1262.h w25q512jvfim.h
  group middleware
    middleware/: fdcan_protocol.h file_system.h
