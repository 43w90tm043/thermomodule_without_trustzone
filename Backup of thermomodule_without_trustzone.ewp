# IAR project Backup of thermomodule_without_trustzone.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32U385CG ST STM32U385CG
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCIncludePath2: CMSIS\; CMSIS\DSP\; libraries\; drivers\; application\; middleware\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: thermomodule_without_trustzone.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: CMSIS\stm32u385xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group (top)
    ./: main.cpp
  group application
    application/: can_protocol.h flash.h thermo.h
  group CMSIS
    CMSIS/: armv8m_mpu.h armv8m_pmu.h cmsis_compiler.h cmsis_iccarm.h cmsis_iccarm_m.h cmsis_version.h core_cm33.h partition_stm32u385xx.h partition_stm32u3xx.h startup_stm32u385xx.s stm32u385xx.h stm32u3xx.h system_stm32u3xx.c system_stm32u3xx.h tz_context.h
  group drivers
    drivers/: clock.h crc.h fdcan.h gpdma.h gpio.h lptim.h octospi.h rng.h rtc.h sleep.h spi.h spilite.h swo.h tim.h wdg.h
  group libraries
    libraries/: ads1262.h w25q512jvfim.h
  group middleware
    middleware/: canard.c canard.h cavl2.h fdcan_protocol.h file_system.h
